v {xschem version=3.4.7 file_version=1.2
}
G {}
K {type=subcircuit
}
V {}
S {}
E {}
C {devices/iopin.sym} -700 -600 0 0 {name=p1 lab=VDDIO}
C {devices/iopin.sym} -700 -560 0 0 {name=p2 lab=VDD}
C {devices/iopin.sym} -700 -520 0 0 {name=p3 lab=VSS}
T {sky130_ioring_corner: rail-only corner cell (CELL.7): rails turn 90 degrees, no pad, no devices.} -700 -760 0 0 0.3 0.3 {}
T {Empty subcircuit body on purpose.} -700 -742 0 0 0.3 0.3 {}
